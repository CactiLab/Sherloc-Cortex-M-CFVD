# Keil uVision project Vulfoo_FreeRTOS_MPU_ns_O3.uvprojx, settings and files
target FVP (6180000::V6.18::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.0
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FreeRTOS_MPU_ns
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\RTE\Device\IOTKit_CM33_FP\ac6_arm.sct
  group Source Group 1
    ./: main_ns.c
  group CMSE Library
    ../../../Sherloc_runtime/lib/: Sherloc_s_IRQ_Lib.o
    ../../../Sherloc_runtime/inc/: Secure_Functions.h
  group Documentation
    ../: README.md
  group FreeRTOS
    ../../../Sherloc_runtime/freertos/: list.c queue.c tasks.c timers.c stream_buffer.c event_groups.c
    ../../../Sherloc_runtime/freertos/portable/MemMang/: heap_4.c
    ../Config/: FreeRTOSConfig.h
    ../../../Sherloc_runtime/freertos/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portmacro.h
    ../../../Sherloc_runtime/freertos/portable/Common/: mpu_wrappers.c
  group BEEBs
    ../../../Sherloc_runtime/evaluation/src/crc32/: crc_32.c
    ../../../Sherloc_runtime/evaluation/: BEEBS.c BEEBS.h
target V2M-MPS2+ (6190000::V6.19::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.0
  cpu: as above
  output: FreeRTOS_MPU_ns
  c flags: Optim=4 v6Lang=5 v6Lto=1 wLevel=1
  c include: .\;..\Config;..\..\..\Sherloc_runtime\inc;..\..\..\Sherloc_runtime\freertos\include;..\..\..\Sherloc_runtime\freertos\portable\GCC\ARM_CM33\secure;..\..\..\Sherloc_runtime\freertos\portable\GCC\ARM_CM33\non_secure;..\..\..\Sherloc_runtime\evaluation\support
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\RTE\Device\IOTKit_CM33_FP\ac6_arm.sct
software components: CMSIS:CORE 5.5.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Device:Startup 1.2.0
