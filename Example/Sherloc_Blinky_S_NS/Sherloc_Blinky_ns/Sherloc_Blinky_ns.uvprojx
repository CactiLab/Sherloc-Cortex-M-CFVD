# Keil uVision project Sherloc_Blinky_ns.uvprojx, settings and files
target V2M-MPS2+ (6190000::V6.19::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.0
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Sherloc_Blinky_ns
  c flags: Optim=4 v6Lang=5 v6Lto=1 wLevel=1
  c define: __USE_LCD  __USE_FPGA
  c include: .\
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\RTE\Device\IOTKit_CM33_FP\ac6_arm.sct
  group Source Group 1
    ./: main_ns.c
    ../../../Sherloc_runtime/inc/: Secure_Functions.h
  group CMSE Library
    ../Sherloc_Blinky_s/Objects/: Sherloc_Blinky_s_CMSE_Lib.o
  group Documentation
    ../: README.md
software components: CMSIS:CORE 5.5.0, Board Support:Buttons 2.0.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, CMSIS Driver:USART 1.0.0, Device:Startup 1.2.0
